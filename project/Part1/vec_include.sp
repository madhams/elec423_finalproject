.VEC '{$Project_DIR}/Part1/sim_vec_function.vec'
